options:
  parameters:
    generate_options: qt_gui
    id: litepcie_test
    output_language: python
    title: LiteX PCIe Test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 4096*100
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_null_source_0_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '10000.0'
    type: float
  states: {}
- name: blocks_probe_rate_0_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '10000.0'
    type: float
  states: {}
- name: litepcie_chan0
  id: litexgnu_litexgnu
  parameters:
    device_index: '0'
  states: {}
- name: litepcie_chan1
  id: litexgnu_litexgnu
  parameters:
    device_index: '1'
  states: {}

connections:
- [blocks_null_source_0, '0', litepcie_chan0, '0']
- [blocks_null_source_0_0, '0', litepcie_chan1, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_probe_rate_0_0, rate, blocks_message_debug_0_0, print]
- [litepcie_chan0, '0', blocks_probe_rate_0, '0']
- [litepcie_chan1, '0', blocks_probe_rate_0_0, '0']

metadata:
  file_format: 1
